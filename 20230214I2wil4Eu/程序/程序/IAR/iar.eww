<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x5355;&#x7247;&#x673A;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


